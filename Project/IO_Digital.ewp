# IAR project IO_Digital.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: F:\Projetos\Renesas\FEI\MiniProjeto1\Drivers\Headers; F:\Projetos\Renesas\FEI\MiniProjeto1\Control\Headers; F:\Projetos\Renesas\FEI\MiniProjeto1
  ARL78.AsmIncludePath: F:\Projetos\Renesas\FEI\MiniProjeto1\Drivers\Headers; F:\Projetos\Renesas\FEI\MiniProjeto1\Control\Headers
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: IO_Digital.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ./: Hardware.h Hooks.h main.c Types.h
  group Headers/Control
    Control/Headers/: CTRL_Button.h CTRL_Leds.h
  group Headers/Drivers
    Drivers/Headers/: DRV_Leds.h
  group Source/Control
    Control/Source/: CTRL_Button.c CTRL_Leds.c
  group Source/Drivers
    Drivers/Source/: DRV_Leds.c
